# Keil uVision project SPI.uvprojx, settings and files
target Target 1 (6140000::V6.14::ARMCLANG)
  device: STM32F411VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: SPI
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=1
  c include: .\ioLibrary_Driver-master;.\ioLibrary_Driver-master\Ethernet;.\ioLibrary_Driver-master\Ethernet\W5500
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group W5500 lib
    ./ioLibrary_Driver-master/Ethernet/W5500/: w5500.c w5500.h
    ./ioLibrary_Driver-master/Ethernet/: socket.c socket.h
    ./: Spi.c wizchip_conf.c wizchip_conf.h
software components: CMSIS:CORE 5.4.0, Device:Startup 2.6.3
