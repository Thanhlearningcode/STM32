# Keil uVision project RR.uvprojx, settings and files
target Target 1 (6140000::V6.14::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: RR +hex
  c flags: OneElfS=1 uGnu=1 v6Lang=1 v6LangP=5 wLevel=1
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group App
    ./: main.c
  group Kernel
    ./: kernel.c kernel.h kernel.S
  group Uart
    ./: uart.c uart.h
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.0
